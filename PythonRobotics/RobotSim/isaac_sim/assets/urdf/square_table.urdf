Commit message: add isaac ur5e

File: PythonRobotics/RobotSim/isaac_sim/assets/urdf/square_table.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link box: geometry collision box size=1.8 1.0 0.1; visual box size=1.8 1.0 0.1
